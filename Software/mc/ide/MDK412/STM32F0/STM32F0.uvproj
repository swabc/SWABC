# Keil uVision project STM32F0.uvproj, settings and files
target STM32F0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: swabc +hex
  AfterMake: copy2out.bat
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F072
  c misc: --C99
  c include: ..\..\..\src\csw\3rdParty\ARM_CMSIS\Device\ST\STM32F0xx\Include;..\..\..\src\csw\3rdParty\ARM_CMSIS\Include;..\..\..\src\csw\3rdParty\STM32F0xx_StdPeriph_Driver\inc;..\..\..\src\bsw_F0\MDK412;..\..\..\src\bsw_F0\;..\..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../src/csw/3rdParty/ARM_CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group STM32F0_StdPeriph_Driver
    ../../../src/csw/3rdParty/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group CSW/framework
    ../../../src/csw/framework/bisch/: bisch.c
  group BSW/MDK412
    ../../../src/bsw_F0/MDK412/: main.c system_stm32f0xx.c
  group BSW/MSP
    ../../../src/bsw_F0/msp/: mcu.c mdo.c mvect.c
  group BSW/Cfg
    ../../../src/bsw_F0/cfg/: cfg_bisch.c
  group ASW/Demo
    ../../../src/asw/demo/: demo0.h demo1.h demo0.c
  group ASW/Cfg
    ../../../src/asw/cfg/: cfg_demo0.c cfg_demo1.c cfg_bsw.c
